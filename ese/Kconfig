## ese/Kconfig
```kconfig
config NXP_ESE_SN1XX
	bool "Nxp ESE sn1xx Controller"
	
config NXP_ESE_PN8XT
	bool "Nxp ESE pn8xt Controller"
	
```
